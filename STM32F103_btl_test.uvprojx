# Keil uVision project STM32F103_btl_test.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_btl_test +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103xB,STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c flash.c gpio.c iwdg.c rcc.c tim.c uart.c
  group inc
    ./: flash.h gpio.h iwdg.h main.h rcc.h tim.h uart.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
